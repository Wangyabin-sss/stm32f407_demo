# Keil uVision project 001.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 001 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\SYSTEM\FSMC;..\SYSTEM\KEY;..\SYSTEM\LED;..\SYSTEM\SYS;..\SYSTEM\TIM;..\SYSTEM\USART;..\SYSTEM\HC-SR04;..\SYSTEM\DHT;..\SYSTEM\ESP8266;..\SYSTEM\SPI;..\SYSTEM\WDG;..\SYSTEM\RTC;..\SYSTEM\FLASH;..\SYSTEM\ADC;..\SYSTEM\IIC;..\SYSTEM\IIC\eMPL;..\SYSTEM\PAJ7620U2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_pwr.c stm32f4xx_flash.c
  group SYSTEM
    ../SYSTEM/FSMC/: fsmc.c
    ../SYSTEM/KEY/: key.c keyboard.c
    ../SYSTEM/LED/: led.c
    ../SYSTEM/SYS/: Sys.c
    ../SYSTEM/TIM/: timer.c
    ../SYSTEM/USART/: usart.c
    ../SYSTEM/HC-SR04/: hc_sr04.c
    ../SYSTEM/DHT/: dht11.c
    ../SYSTEM/ESP8266/: mqtt.c
    ../SYSTEM/SPI/: spi.c xpt2046.c w25qxx.c mfrc522.c nrf24l01.c
    ../SYSTEM/WDG/: iwdg.c
    ../SYSTEM/RTC/: rtc.c
    ../SYSTEM/FLASH/: flash.c
    ../SYSTEM/ADC/: adc.c
    ../SYSTEM/IIC/: iic.c at24cxx.c oled.c MPU6050.c
    ../SYSTEM/IIC/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../SYSTEM/PAJ7620U2/: paj7620u2.c paj7620u2_iic.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group README
    ../: README.md
